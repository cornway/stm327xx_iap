# Keil uVision project Project.uvprojx, settings and files
target bootloader-h747-m4 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32H747XIHx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: fromelf obj-h7\cm4\%L --bin --output=obj-h7\cm4\bin\Project.bin
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32H747xx,USE_HAL_DRIVER,USE_STM32H747I_DISCO,STM32_SDK,__ARCH_ARM_M4__,CORE_CM4,BSP_INDIR_API,VECT_TAB_SRAM
  c include: ..\common\STM32H7xx_Driver\CMSIS\Include;../common/STM32H7xx_Driver/CMSIS/Device/ST/STM32H7xx/Include;../common/STM32H7xx_Driver/Inc;../common/STM32H7xx_Driver/BSP/STM32H747I-DISCO;../common/STM32H7xx_Driver/BSP/Components/Common;../common/Utilities/Fonts;../common/Utilities/CPU;../common/Middlewares/ST/STM32_Audio/Addons/PDM/Inc;..\ulib\pub;..\configs\stm32h745-disco;..\ulib\arch
  library: MicroLIB
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\default-h7-cm4.sct
  group main-h7-m4
    ../common/hal/: hal_cm4_main.c
    ../main/Src/: main-cm4.c
    ../common/STM32H7xx_Driver/BSP/STM32H747I-DISCO/: system_stm32h7xx.c
  group hal-h7
    ./stm32h745-hal-lib-cm4/: hal-cm4.lib
    ./stm32h745-hal-lib/: hal.lib
    ../common/Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM7_Keil_wc16.lib
  group hal-bsp
    ../common/hal/: audio_hal.c bhal.c bsp_mod.c codeswap.c gui_hal.c hal_main.c jpeg_hal.c lcd_hal.c mpu.c nvic.c retarget.c sd_diskio.c spi_int.c tim.c uart_hal.c smp.c
    ../common/int/: it_export.h
  group ulib
    ../ulib/pub/: bsp_api.c dev_main.c ulib_main.c
    ../ulib/io/: in_ctlr.c fs_io_pub.c dev_io.c
    ../ulib/io/fs/FatFs/src/: ff_gen_drv.c ff.c diskio.c
    ../ulib/audio/: audio_ext.c audio_main.c audio_mem.c audio_mix.c cdtrack.c
    ../ulib/boot/: baudio.c binput.c bmain.c boot_cmd.c bres_loader.c bsfx.c
    ../ulib/drv/: gamepad-def.c gamepad-gp-50.c
    ../ulib/gfx/: gfx2d_mem.c jpeg.c
    ../ulib/gui/: gui_main.c gui_math.c gui_win.c
    ../ulib/hdmi/: hdmi_mem.c
    ../ulib/lib/: dmalloc.c dstring.c
    ../ulib/mem/: heap.c
    ../ulib/misc/: bsp_cmd.c serial.c profiler.c term.c
    ../ulib/screen/: screen_std.c
    ../ulib/screen/stm32/: lcd.c
    ../ulib/misc/src/: swtim.cpp new.cpp
    ../ulib/usb/stm32/: usb_hid_gamepad.c
  group asm
    ../ulib/arch/Arm/m7/src/: asm_utils.s machM7.s cm4_code.s
  group components-h747i
    ../common/STM32H7xx_Driver/BSP/Components/adv7533/: adv7533.c adv7533_reg.c
    ../common/STM32H7xx_Driver/BSP/Components/ft6x06/: ft6x06.c ft6x06_reg.c
    ../common/STM32H7xx_Driver/BSP/Components/is42s32800j/: is42s32800j.c
    ../common/STM32H7xx_Driver/BSP/Components/wm8994/: wm8994.c wm8994_reg.c
    ../common/STM32H7xx_Driver/BSP/Components/otm8009a/: otm8009a.c otm8009a_reg.c
  group bsp-h747i
    ../common/STM32H7xx_Driver/BSP/STM32H747I-DISCO/: stm32h747i_discovery.c stm32h747i_discovery_audio.c stm32h747i_discovery_bus.c stm32h747i_discovery_lcd.c stm32h747i_discovery_sd.c stm32h747i_discovery_sdram.c stm32h747i_discovery_ts.c
  group utils
    ../common/Utilities/Fonts/: font8.c font20.c font24.c font16.c font12.c
    ../common/Utilities/Basic_GUI/: basic_gui.c
    ../common/Utilities/JPEG/: jpeg_utils.c
  group startup
    ./: startup_stm32h747xx.s startup_stm32h747xx-m4.s
  group main-h7
    ../main/Src/: main.c
    ../common/STM32H7xx_Driver/BSP/STM32H747I-DISCO/: system_stm32h7xx.c
  group hal-h7xx-src
    ../common/STM32H7xx_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_comp.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_dfsdm_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dsi.c stm32h7xx_hal_dts.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gfxmmu.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hash.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_hcd.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_irda.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_lptim.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdios.c stm32h7xx_hal_mdma.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_msp_template.c stm32h7xx_hal_nand.c stm32h7xx_hal_nor.c stm32h7xx_hal_opamp.c stm32h7xx_hal_opamp_ex.c stm32h7xx_hal_ospi.c stm32h7xx_hal_otfdec.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pssi.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_ramecc.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rng_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_smartcard.c stm32h7xx_hal_smartcard_ex.c stm32h7xx_hal_smbus.c stm32h7xx_hal_spdifrx.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_swpmi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_timebase_rtc_alarm_template.c stm32h7xx_hal_timebase_rtc_wakeup_template.c stm32h7xx_hal_timebase_tim_template.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_wwdg.c stm32h7xx_ll_adc.c stm32h7xx_ll_bdma.c stm32h7xx_ll_comp.c stm32h7xx_ll_crc.c stm32h7xx_ll_crs.c stm32h7xx_ll_dac.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_dma.c stm32h7xx_ll_dma2d.c stm32h7xx_ll_exti.c stm32h7xx_ll_fmc.c stm32h7xx_ll_gpio.c stm32h7xx_ll_hrtim.c stm32h7xx_ll_i2c.c stm32h7xx_ll_lptim.c stm32h7xx_ll_lpuart.c stm32h7xx_ll_mdma.c stm32h7xx_ll_opamp.c stm32h7xx_ll_pwr.c stm32h7xx_ll_rcc.c stm32h7xx_ll_rng.c stm32h7xx_ll_rtc.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_spi.c stm32h7xx_ll_swpmi.c stm32h7xx_ll_tim.c stm32h7xx_ll_usart.c stm32h7xx_ll_usb.c stm32h7xx_ll_utils.c
  group usb-h747
    ../ulib/usb/stm32/h747/: usbh_conf.c usbh_core.c usbh_ctlreq.c usbh_hid.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_hid_parser.c usbh_ioreq.c usbh_pipes.c
  group usb-f769
    ../ulib/usb/stm32/f769/: usb_hid_gamepad.c usbh_conf.c usbh_core.c usbh_ctlreq.c usbh_hid.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_hid_parser.c usbh_ioreq.c usbh_pipes.c
  group ulib-h7-m4
    ../ulib/gfx/: gfx2d_mem.c
    ../common/hal/: smp.c codeswap.c
    ../ulib/lib/: dstring.c dmalloc.c dmisc.c
    ../ulib/pub/: bsp_api.c
target bootloader-h747-m7 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.4.0
  cpu: IRAM(0x38000000,0x00010000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32H747xx,USE_HAL_DRIVER,USE_STM32H747I_DISCO,DATA_IN_ExtSDRAM,USE_LCD_HDMI,USE_USB_HS,STM32_SDK,BOOT,BSP_DRIVER,HAVE_CODESWAP,__ARCH_ARM_M7__,CORE_CM7,USE_SMP
  c misc: --cpp11 --gnu
  c include: ..\common\STM32H7xx_Driver\CMSIS\Include;..\common\STM32H7xx_Driver\CMSIS\Device\ST\STM32H7xx\Include;..\common\STM32H7xx_Driver\Inc;..\common\STM32H7xx_Driver\BSP\Components\Common;..\common\STM32H7xx_Driver\BSP\STM32H747I-DISCO;..\ulib\pub;..\ulib\boot\inc;..\ulib\arch;..\main\Inc;..\configs\stm32h745-disco;..\common\int;..\common\Utilities\JPEG;..\ulib\io\fs\FatFs\src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0xd0000000 size 0x2000000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\default-h7.sct
target hal-h7 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.4.0
  cpu: as above
  output: hal (library)
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\default-h7.sct
